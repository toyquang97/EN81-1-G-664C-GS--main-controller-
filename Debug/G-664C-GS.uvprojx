# Keil uVision project G-664C-GS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: G-664C-GS +hex
  c flags: oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\mcu-c.sct
  group Source Group 1
    ./: startup_LPC17xx.s
    ../src/: arrival.c call.c can.c can_a.c can_b.c can_c.c can_err.c cycle.c dict.c diving.c door_op.c doortest.c drive.c drv_err.c eeprom.c em_op.c err_rel.c error.c ese.c evac.c exe.c hb_err.c history.c hwtest.c i2c.c init.c input.c insp.c io.c lcd.c load.c main.c mcp2515.c menu.c moving.c nice5000.c no_setup.c parameter.c pos.c relev.c res_trip.c rtc.c sc_error.c set_para.c sp_trip.c start.c state.c still.c teach.c temperature.c term.c test.c text.c timer.c tse.c version.c wait.c
software components: CMSIS:CORE 5.4.0
